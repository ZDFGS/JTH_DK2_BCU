# Keil uVision project CF_EBCU.uvproj, settings and files
target Target 1 (166/167)
  device: XE167F-96F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xA000-0xDFFF) XRAM2(0xE00000-0xE0FFFF) IROM(0xC00000-0xC0EFFF) IROM2(0xC10000-0xCBFFFF) CLOCK(20000000) MOD167 MODV2
  output: CF_EBCU +hex
  group Dave Files
    ./: Start_V3.A66 MAIN.C SCS.C IO.C U2C0.C USIC2.C GPT1.C GPT2.C WDT.C CC2.C CAN.C
  group Driver Files
    ./Hardward File/: DIO.c Delay.c AIO.c glable.c canDrive.c protocol.c pid.c PWM.c
  group User_App
    ./User_App/: global.c init.c input.c self_check.c brake_control.c
